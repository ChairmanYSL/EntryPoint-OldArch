# IAR project entrypoint_kernel.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\inc; ..\..\include; ..\..\src\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: entrypoint_kernel.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../src/: emv.c emv_kernel.c emv_application_selection.c emv_combination_Selection.c emv_selec_kernel.c emvapi.c emvbuf.c emvicc.c emvoutcome.c emvporting.c emvsdk.c emvspi.c emvtag.c emvtlv.c
