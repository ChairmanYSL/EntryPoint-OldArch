#include "emv_tag.h"
#include "emvi.h"


static const EMV_TAG_ITEM g_emv_tag_lib[]=
{
	{TAG_0042_IIN, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 0, 3, EMVTAGFORMAT_B, EMVTAGTYPE_PURE},
	{TAG_004F_AID, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 0, 16, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_0050_APPLICATION_LABEL, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 0, 16, EMVTAGFORMAT_ANS, EMVTAGTYPE_ALL},
	{TAG_0056_TRACK1DATA,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA,0,76,EMVTAGFORMAT_ANS,EMVTAGTYPE_PAYPASS|EMVTAGTYPE_DPAS},
	{TAG_0057_TRACK2_EQUIVALENT_DATA, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 0, 19, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_005A_APPLICATION_PAN, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 0, 10, EMVTAGFORMAT_CN, EMVTAGTYPE_ALL},
	{TAG_0061_APPLICATION_TEMPLATE, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 0, 252, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_006F_FCI_TEMPLATE, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 0, 252, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_0070_AEF_DATA_TEMPLATE, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 0, 255, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_0071_ISSUER_SCRIPT_TEMPLATE_1, EMVTAGUPDATECONDITION_K, 0, 255, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_0072_ISSUER_SCRIPT_TEMPLATE_2, EMVTAGUPDATECONDITION_K, 0, 255, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_0073_DIRECTORY_DISCRETIONARY_TEMPLATE, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 0, 252, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_0077_RESPONSE_MESSAGE_TEMPLATE_FORMAT_2, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 0, 255, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_0080_RESPONSE_MESSAGE_TEMPLATE_FORMAT_1, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 0, 255, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_0081_AMOUNT_AUTHORISED_BINARY, EMVTAGUPDATECONDITION_K, 4, 4, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_0082_AIP, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 2, 2, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_0084_DF_NAME, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 5, 16, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_0086_ISSUER_SCRIPT_COMMAND, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 0, 125, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_0087_API, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 0, 1, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_0088_SFI, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 1, 1, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_0089_AUTH_CODE, EMVTAGUPDATECONDITION_K, 6, 6, EMVTAGFORMAT_ANS, EMVTAGTYPE_ALL},
	{TAG_008A_ARC, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 2, 2, EMVTAGFORMAT_ANS, EMVTAGTYPE_ALL},
	{TAG_008B_POI_INFOMATION,EMVTAGUPDATECONDITION_K,0,64,EMVTAGFORMAT_B,EMVTAGTYPE_ALL},
	{TAG_008C_CDOL_1, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 0, 252, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_008D_CDOL_2, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 0, 252, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_008E_CVM_LIST, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 0, 252, EMVTAGFORMAT_B, (EMVTAGTYPE_ALL&(~EMVTAGTYPE_PAYPASS))},
	{TAG_008E_CVM_LIST, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 10, 252, EMVTAGFORMAT_B, EMVTAGTYPE_PAYPASS},
	{TAG_008F_CERTIFICATION_AUTHORITY_PUBLIC_KEY_INDEX, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 1, 1, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_0090_ISSUER_PUBLIC_KEY_CERTIFICATE, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 0, 248, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_0091_ISSUER_AUTHENTICATION_DATA, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 8, 16, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_0092_ISSUER_PUBLIC_KEY_REMAINDER, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 0, 128, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_0093_SIGNED_STATIC_APPLICATION_DATA, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 64, 248, EMVTAGFORMAT_B, (EMVTAGTYPE_ALL & (~EMVTAGTYPE_PAYPASS))},
	{TAG_0093_SIGNED_STATIC_APPLICATION_DATA, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 1, 248, EMVTAGFORMAT_B, EMVTAGTYPE_PAYPASS},
	{TAG_0094_AFL, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 0, 252, EMVTAGFORMAT_B, (EMVTAGTYPE_ALL&(~EMVTAGTYPE_PAYPASS))},
	{TAG_0094_AFL, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 4, 248, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_0095_TVR, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 5, 5, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_0097_TDOL, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 0, 252, EMVTAGFORMAT_B, EMVTAGTYPE_EMVCONTACT},
	{TAG_0098_TC_HASH_VALUE, EMVTAGUPDATECONDITION_K, 20, 20, EMVTAGFORMAT_B, EMVTAGTYPE_EMVCONTACT},
	{TAG_0099_TRANSACTION_PIN_DATA, EMVTAGUPDATECONDITION_K, 0, 255, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_009A_TRANSACTION_DATE, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_ACT|EMVTAGUPDATECONDITION_DET, 3, 3, EMVTAGFORMAT_N, EMVTAGTYPE_ALL},
	{TAG_009B_TSI, EMVTAGUPDATECONDITION_K, 2, 2, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_009C_TRANSACTION_TYPE, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_ACT|EMVTAGUPDATECONDITION_DET, 1, 1, EMVTAGFORMAT_N, EMVTAGTYPE_ALL},
	{TAG_009D_DDF_NAME, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 5, 16, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_00A5_FCI_PROPRIETARY_TEMPLATE, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 0, 255, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_5F20_CARDHOLDER_NAME,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA,0,255,EMVTAGFORMAT_ANS,(EMVTAGTYPE_ALL&(~EMVTAGTYPE_PAYPASS)&(~EMVTAGTYPE_JCB))},
	{TAG_5F20_CARDHOLDER_NAME,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA,2,26,EMVTAGFORMAT_ANS,EMVTAGTYPE_JCB},
	{TAG_5F24_APPLICATION_EXPIRATION_DATE, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 3, 3, EMVTAGFORMAT_N, EMVTAGTYPE_ALL},
	{TAG_5F25_APPLICATION_EFFECTIVE_DATE, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 3, 3, EMVTAGFORMAT_N, EMVTAGTYPE_ALL},
	{TAG_5F28_ISSUER_COUNTRY_CODE, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 2, 2, EMVTAGFORMAT_N, EMVTAGTYPE_ALL},
	{TAG_5F2A_TRANSACTION_CURRENCY_CODE, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_ACT|EMVTAGUPDATECONDITION_DET, 2, 2, EMVTAGFORMAT_N, EMVTAGTYPE_ALL},
	{TAG_5F2D_LANGUAGE_PREFERENCE, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 2, 8, EMVTAGFORMAT_AN, EMVTAGTYPE_ALL},
	{TAG_5F30_SERVICE_CODE, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 2, 2, EMVTAGFORMAT_N, EMVTAGTYPE_ALL},
	{TAG_5F34_APPLICATION_PAN_SEQUENCE, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 1, 1, EMVTAGFORMAT_N, EMVTAGTYPE_ALL},
	{TAG_5F36_TRANSACTION_CURRENCY_EXPONENT, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_ACT|EMVTAGUPDATECONDITION_DET, 1, 1, EMVTAGFORMAT_N, EMVTAGTYPE_ALL},
	{TAG_5F50_ISSUER_URL,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA,0,255,EMVTAGFORMAT_ANS,EMVTAGTYPE_ALL},
//	{TAG_5F53_IBAN, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA|EMVTAGUPDATECONDITION_ACT|EMVTAGUPDATECONDITION_DET, 0, 34, EMVTAGFORMAT_ANS, EMVTAGTYPE_PAYPASS},
	{TAG_5F57_ACCOUNT_TYPE, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_ACT|EMVTAGUPDATECONDITION_DET, 1, 1, EMVTAGFORMAT_N, EMVTAGTYPE_PAYPASS},
	{TAG_9F01_ACQUIRER_IDENTIFIER, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_ACT|EMVTAGUPDATECONDITION_DET, 6, 6, EMVTAGFORMAT_N, EMVTAGTYPE_ALL},
	{TAG_9F02_AMOUNT_AUTHORISED_NUMERIC, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_ACT|EMVTAGUPDATECONDITION_DET, 6, 6, EMVTAGFORMAT_N, EMVTAGTYPE_ALL},
	{TAG_9F03_AMOUNT_OTHER_NUMERIC, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_ACT|EMVTAGUPDATECONDITION_DET, 6, 6, EMVTAGFORMAT_N, EMVTAGTYPE_ALL},
	{TAG_9F04_AMOUNT_OTHER_BINARY, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_ACT|EMVTAGUPDATECONDITION_DET, 4, 4, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_9F05_APPLICATION_DISCRETIONARY_DATA, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_ACT|EMVTAGUPDATECONDITION_RA, 0, 32, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_9F06_AID_TERMINAL, EMVTAGUPDATECONDITION_K, 5, 16, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_9F07_AUC, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 2, 2, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_9F08_APPLICATION_VERSION_NUMBER_CARD, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 2, 2, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_9F09_APPLICATION_VERSION_NUMBER_TERMINAL, EMVTAGUPDATECONDITION_K, 2, 2, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_9F0A_ASRPD,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA,0,255,EMVTAGFORMAT_AN,(EMVTAGTYPE_ALL & (~EMVTAGTYPE_PAYPASS))},
	{TAG_9F0B_CARDHOLDER_NAME_EXTENDED, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 0, 255, EMVTAGFORMAT_ANS, (EMVTAGTYPE_ALL&(~EMVTAGTYPE_PAYPASS))},
	{TAG_9F0B_CARDHOLDER_NAME_EXTENDED, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 27, 45, EMVTAGFORMAT_ANS, EMVTAGTYPE_PAYPASS},
	{TAG_9F0D_ISSUER_ACTION_CODE_DEFAULT, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 5, 5, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_9F0E_ISSUER_ACTION_CODE_DENIAL, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 5, 5, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_9F0F_ISSUER_ACTION_CODE_ONLINE, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 5, 5, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_9F10_IAD, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 0, 32, EMVTAGFORMAT_B, (EMVTAGTYPE_ALL&(~EMVTAGTYPE_PURE))},
	{TAG_9F10_IAD, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 0, 34, EMVTAGFORMAT_B, EMVTAGTYPE_PURE},
	{TAG_9F11_ISSUER_CODE_TABLE_INDEX, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 1, 1, EMVTAGFORMAT_N, EMVTAGTYPE_ALL},
	{TAG_9F12_APPLICATION_PREFERRED_NAME, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 0, 16, EMVTAGFORMAT_ANS, EMVTAGTYPE_ALL},
	{TAG_9F13_LAST_ONLINE_ATC_REGISTER, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 2, 2, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_9F14_LOWER_CONSECUTIVE_OFFLINE_LIMIT, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 1, 1, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_9F15_MERCHANT_CATEGORY_CODE, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 2, 2, EMVTAGFORMAT_N, EMVTAGTYPE_ALL},
	{TAG_9F16_MERCHANT_IDENTIFIER, EMVTAGUPDATECONDITION_K, 15, 15, EMVTAGFORMAT_ANS, EMVTAGTYPE_ALL},
	{TAG_9F17_PIN_TRY_COUNTER, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 1, 1, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_9F18_ISSUER_SCRIPT_IDENTIFIER, EMVTAGUPDATECONDITION_K, 4, 4, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_9F1A_TERMINAL_COUNTRY_CODE, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 2, 2, EMVTAGFORMAT_N, EMVTAGTYPE_ALL},
	{TAG_9F1B_TERMINAL_FLOOR_LIMIT, EMVTAGUPDATECONDITION_K, 4, 4, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_9F1C_TERMINAL_IDENTIFICATION, EMVTAGUPDATECONDITION_K, 8, 8, EMVTAGFORMAT_AN, EMVTAGTYPE_ALL},
	{TAG_9F1D_TERMINAL_RISK_MANGEMENT_DATA, EMVTAGUPDATECONDITION_K, 1, 8, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_9F1E_IFD_SERIAL_NUMBER, EMVTAGUPDATECONDITION_K, 8, 8, EMVTAGFORMAT_AN, EMVTAGTYPE_ALL},
	{TAG_9F1F_TRACK1_DISCRETIONARY_DATA, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 0, 128, EMVTAGFORMAT_ANS, EMVTAGTYPE_ALL},
	{TAG_9F20_TRACK2_DISCRETIONARY_DATA, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 0, 128, EMVTAGFORMAT_CN, EMVTAGTYPE_ALL},
	{TAG_9F21_TRANSACTION_TIME, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_ACT|EMVTAGUPDATECONDITION_DET, 3, 3, EMVTAGFORMAT_N, EMVTAGTYPE_ALL},
	{TAG_9F22_CAPK_INDEX, EMVTAGUPDATECONDITION_K, 1, 1, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_9F23_UPPER_CONSECUTIVE_OFFLINE_LIMIT, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 1, 1, EMVTAGFORMAT_B, EMVTAGTYPE_EMVCONTACT},
	{TAG_9F24_PAYMENT_ACCOUNT_REFERENCE,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA|EMVTAGUPDATECONDITION_DET,29,29,EMVTAGFORMAT_AN,(EMVTAGTYPE_ALL & (~EMVTAGTYPE_RUPAY))},
	{TAG_9F24_PAYMENT_ACCOUNT_REFERENCE,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA,0,255,EMVTAGFORMAT_AN,EMVTAGTYPE_RUPAY | EMVTAGTYPE_PAYWAVE},
	{TAG_9F26_APPLICATION_CRYPTOGRAM, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 8, 8, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_9F27_CRYPTOGRAM_INFO_DATA, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 1, 1, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_9F2A_KERNEL_ID, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 1, 1, EMVTAGFORMAT_B, (EMVTAGTYPE_ALL & (~EMVTAGTYPE_PAYPASS))},
	{TAG_9F2D_ICC_PIN_ENCIPHERMENT_PUBLIC_KEY_CERTIFICATE, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 0, 248, EMVTAGFORMAT_B, EMVTAGTYPE_EMVCONTACT},
	{TAG_9F2E_ICC_PIN_ENCIPHERMENT_PUBLIC_KEY_EXPONENT, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 1, 3, EMVTAGFORMAT_B, EMVTAGTYPE_EMVCONTACT},
	{TAG_9F2F_ICC_PIN_ENCIPHERMENT_PUBLIC_KEY_REMAINDER, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 0, 42, EMVTAGFORMAT_B, EMVTAGTYPE_EMVCONTACT},
	{TAG_9F32_ISSUER_PUBLIC_KEY_EXPONENT, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 1, 3, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_9F33_TERMINAL_CAPABILITIES, EMVTAGUPDATECONDITION_K, 3, 3, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_9F34_CVM_RESULTS, EMVTAGUPDATECONDITION_K, 3, 3, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_9F35_TERMINAL_TYPE, EMVTAGUPDATECONDITION_K, 1, 1, EMVTAGFORMAT_N, EMVTAGTYPE_ALL},
	{TAG_9F36_ATC, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 2, 2, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_9F37_UNPREDICATABLE_NUMBER, EMVTAGUPDATECONDITION_K, 4, 4, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_9F38_PDOL, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 0, 252, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_9F39_POS_ENTRY_MODE, EMVTAGUPDATECONDITION_K, 1, 1, EMVTAGFORMAT_N, EMVTAGTYPE_ALL},
	{TAG_9F3A_AMOUNT_REFERENCE_CURRENCY, EMVTAGUPDATECONDITION_K, 4, 4, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_9F3B_APPLICATION_REFERENCE_CURRENCY, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 2, 8, EMVTAGFORMAT_N, EMVTAGTYPE_ALL},
	{TAG_9F3C_TRANSACTION_REFERENCE_CURRENCY, EMVTAGUPDATECONDITION_K, 2, 2, EMVTAGFORMAT_N, EMVTAGTYPE_ALL},
	{TAG_9F3D_TRANSACTION_REFERENCE_CURRENCY_EXPONENT, EMVTAGUPDATECONDITION_K, 1, 1, EMVTAGFORMAT_N, EMVTAGTYPE_ALL},
	{TAG_9F3E_TERMINAL_CATEGORIES_SUPPORTED_LIST,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA,0,252,EMVTAGFORMAT_B,EMVTAGTYPE_ALL},
	{TAG_9F3F_SDOL,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA,0,252,EMVTAGFORMAT_B,EMVTAGTYPE_ALL},
	{TAG_9F40_ADDITIONAL_TERMINAL_CAPABILITIES, EMVTAGUPDATECONDITION_K, 5, 5, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_9F41_TRANSACTION_SEQUENCE_COUNTER, EMVTAGUPDATECONDITION_K, 2, 4, EMVTAGFORMAT_N, EMVTAGTYPE_ALL},
	{TAG_9F42_APPLICATION_CURRENCY_CODE, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 2, 2, EMVTAGFORMAT_N, EMVTAGTYPE_ALL},
	{TAG_9F43_APPLICATION_REFERENCE_CURRENCY_EXPONENT, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 1, 4, EMVTAGFORMAT_N, EMVTAGTYPE_ALL},
	{TAG_9F44_APPLICATION_CURRENCY_EXPONENT, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 1, 1, EMVTAGFORMAT_N, EMVTAGTYPE_ALL},
	{TAG_9F45_DATA_AUTHENTICATION_CODE, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 2, 2, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_9F46_ICC_PUBLIC_KEY_CERTIFICATE, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 0, 248, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_9F47_ICC_PUBLIC_KEY_EXPONENT, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 1, 3, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_9F48_ICC_PUBLIC_KEY_REMAINDER, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 0, 128, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_9F49_DDOL, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 0, 252, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_9F4A_SDA_TAG_LIST, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 0, 128, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_9F4B_SIGNED_DYNAMIC_APPLICATION_DATA, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 0, 248, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_9F4C_ICC_DYNAMIC_NUMBER, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 2, 8, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_9F4D_LOG_SFI, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 2, 2, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},
	{TAG_9F4E_MERCHANT_NAME, EMVTAGUPDATECONDITION_K, 0, 80, EMVTAGFORMAT_ANS, EMVTAGTYPE_ALL},
	{TAG_9F4F_LOG_FORMAT, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 0, 252, EMVTAGFORMAT_ANS, EMVTAGTYPE_ALL},
	{TAG_9F51_DRDOL, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 0, 255, EMVTAGFORMAT_B, EMVTAGTYPE_PAYPASS},
	{TAG_9F53_TRANS_CATEGORY_CODE,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_ACT|EMVTAGUPDATECONDITION_DET,1,1,EMVTAGFORMAT_AN,EMVTAGTYPE_PAYPASS},
	{TAG_9F54_DS_ODS_CARD,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA|EMVTAGUPDATECONDITION_DET,0,160,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},
	{TAG_9F5B_DSDOL,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA|EMVTAGUPDATECONDITION_DET,0,250,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},
	{TAG_9F5C_DS_REQ_OPERATOR_ID,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_ACT|EMVTAGUPDATECONDITION_DET,0,8,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},
	{TAG_9F5D_AVAILABLE_OFFLINE_SPENDING_AMOUNT, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 3, 3, EMVTAGFORMAT_B, EMVTAGTYPE_PAYPASS},
    {TAG_9F5D_APP_CAPABILITY_INFO,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA,3,3,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},
	{TAG_9F5E_DS_ID,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA|EMVTAGUPDATECONDITION_DET,8,11,EMVTAGFORMAT_N,EMVTAGTYPE_PAYPASS},
	{TAG_9F5F_DS_SLOT_AVAILABILITY,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA|EMVTAGUPDATECONDITION_DET,1,1,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},
	{TAG_9F60_CVC3_TRACK1, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 2, 2, EMVTAGFORMAT_B, EMVTAGTYPE_PAYPASS},
	{TAG_9F61_CARDHOLDER_DOCUMENTS_NUMBER, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 0, 40, EMVTAGFORMAT_ANS, EMVTAGTYPE_EMVCONTACT},
	{TAG_9F61_CVC3_TRACK2, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 2, 2, EMVTAGFORMAT_B, EMVTAGTYPE_PAYPASS},
	{TAG_9F62_PCVC3_TRACK1,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 6, 6, EMVTAGFORMAT_B, EMVTAGTYPE_PAYPASS},
	{TAG_9F63_PUNATC_TRACK1,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA,6,6,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},
	{TAG_9F64_NATC_TRACK1,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA,1,1,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},
	{TAG_9F65_PCVC3_TRACK2,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA,2,2,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},
	{TAG_9F66_TERMINAL_TRANSACTION_QUALIFIERS, EMVTAGUPDATECONDITION_K, 4, 4, EMVTAGFORMAT_B, EMVTAGTYPE_EMVCONTACT|EMVTAGTYPE_QPBOC|EMVTAGTYPE_PAYWAVE|EMVTAGTYPE_PURE},
	{TAG_9F66_PUNATC_TRACK2, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 2, 2, EMVTAGFORMAT_B, EMVTAGTYPE_PAYPASS},
	{TAG_9F67_NATC_TRACK2, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 1, 1, EMVTAGFORMAT_B, EMVTAGTYPE_PAYPASS},
	{TAG_9F69_CARD_AUTHENTICATION_RELATED_DATA, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 0, 255, EMVTAGFORMAT_B, EMVTAGTYPE_QPBOC|EMVTAGTYPE_PAYWAVE},
	{TAG_9F69_UDOL,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA,0,255,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},
	{TAG_9F6A_UNNUMBER_NUMERIC,EMVTAGUPDATECONDITION_K,4,4,EMVTAGFORMAT_N,EMVTAGTYPE_PAYPASS},
	{TAG_9F6B_PAYPASSMSD_TRACK2DATA,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA,0,19,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},
	{TAG_9F6C_CARD_TRANSACTION_QUALIFIERS, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 2, 2, EMVTAGFORMAT_B, EMVTAGTYPE_QPBOC|EMVTAGTYPE_PAYWAVE|EMVTAGTYPE_DPAS},
	{TAG_9F6D_EC_RESET_THRESHOLD, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 6, 6, EMVTAGFORMAT_N, EMVTAGTYPE_EMVCONTACT},
	{TAG_9F6D_MSD_APPVER_NUM, EMVTAGUPDATECONDITION_K, 2, 2, EMVTAGFORMAT_B, EMVTAGTYPE_PAYPASS},
	{TAG_9F6E_THIRD_PARTY_DATA, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 5, 32, EMVTAGFORMAT_B, EMVTAGTYPE_PAYPASS},
	{TAG_9F6F_DS_SLOT_MANAGE_CTRL,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA|EMVTAGUPDATECONDITION_DET,1,1,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},

	{TAG_9F70_PROTECTED_DATA_ENVELOPE1,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA|EMVTAGUPDATECONDITION_ACT|EMVTAGUPDATECONDITION_DET,0,192,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},
    {TAG_9F71_PROTECTED_DATA_ENVELOPE2,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA|EMVTAGUPDATECONDITION_ACT|EMVTAGUPDATECONDITION_DET,0,192,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},

	{TAG_9F72_PROTECTED_DATA_ENVELOPE3,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA|EMVTAGUPDATECONDITION_ACT|EMVTAGUPDATECONDITION_DET,0,192,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},

	{TAG_9F73_PROTECTED_DATA_ENVELOPE4,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA|EMVTAGUPDATECONDITION_ACT|EMVTAGUPDATECONDITION_DET,0,192,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},

	{TAG_9F74_PROTECTED_DATA_ENVELOPE5,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA|EMVTAGUPDATECONDITION_ACT|EMVTAGUPDATECONDITION_DET,0,192,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},

	{TAG_9F74_EC_ISSUER_AUTHORIZATION_CODE, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 6, 6, EMVTAGFORMAT_AN, EMVTAGTYPE_EMVCONTACT},

	{TAG_9F75_UNPROTECTED_DATA_ENVELOPE1,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA|EMVTAGUPDATECONDITION_ACT|EMVTAGUPDATECONDITION_DET,0,192,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},

	{TAG_9F76_UNPROTECTED_DATA_ENVELOPE2,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA|EMVTAGUPDATECONDITION_ACT|EMVTAGUPDATECONDITION_DET,0,192,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},

	{TAG_9F77_UNPROTECTED_DATA_ENVELOPE3,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA|EMVTAGUPDATECONDITION_ACT|EMVTAGUPDATECONDITION_DET,0,192,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},

	{TAG_9F77_EC_BALANCE_LIMIT, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 6, 6, EMVTAGFORMAT_N, EMVTAGTYPE_EMVCONTACT},

	{TAG_9F78_UNPROTECTED_DATA_ENVELOPE4,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA|EMVTAGUPDATECONDITION_ACT|EMVTAGUPDATECONDITION_DET,0,192,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},

	{TAG_9F78_EC_SINGLE_TRANSACTION_LIMIT, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 6, 6, EMVTAGFORMAT_N, EMVTAGTYPE_EMVCONTACT},

	{TAG_9F79_UNPROTECTED_DATA_ENVELOPE5,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA|EMVTAGUPDATECONDITION_ACT|EMVTAGUPDATECONDITION_DET,0,192,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},

	{TAG_9F79_EC_BALANCE, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 6, 6, EMVTAGFORMAT_N, EMVTAGTYPE_EMVCONTACT},

	{TAG_9F7A_EC_TERMINAL_SUPPORT_INDICATOR, EMVTAGUPDATECONDITION_K, 1, 1, EMVTAGFORMAT_B, EMVTAGTYPE_EMVCONTACT},

	{TAG_9F7B_EC_TERMINAL_TRANSACTION_LIMIT, EMVTAGUPDATECONDITION_K, 6, 6, EMVTAGFORMAT_B, EMVTAGTYPE_EMVCONTACT},

	{TAG_9F7C_MERCHANT_CUSTOM_DATA,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_ACT|EMVTAGUPDATECONDITION_DET,20,20,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},

	{TAG_9F7C_QVSDC_CED, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 1, 32, EMVTAGFORMAT_B, EMVTAGTYPE_PAYWAVE},

	{TAG_9F7D_DS_SUMMARY1,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA|EMVTAGUPDATECONDITION_DET,8,16,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},

	{TAG_9F7E_MOBILE_SUPPORT_INDICATOR, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 1, 32, EMVTAGFORMAT_B, EMVTAGTYPE_PAYWAVE},

	{TAG_9F7E_MOBILE_SUPPORT_INDICATOR, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 1, 1, EMVTAGFORMAT_B, EMVTAGTYPE_PAYPASS},

	{TAG_9F7F_DS_UNPREDICT_NUMBER,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA|EMVTAGUPDATECONDITION_DET,4,4,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},

	{TAG_BF0C_FCI_ISSUER_DISCRETIONARY_DATA, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA, 0, 255, EMVTAGFORMAT_B, EMVTAGTYPE_ALL},

	{TAG_DF4B_POS_CARDHOLDER_INTERACT_INFO,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA,3,3,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},

	{TAG_DF60_DS_INPUT_CARD,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_ACT|EMVTAGUPDATECONDITION_DET,8,8,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},

	{TAG_DF61_DS_DIGEST_H,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_DET,8,8,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},

	{TAG_DF62_DS_ODS_INFO,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_ACT|EMVTAGUPDATECONDITION_DET,1,1,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},

	{TAG_DF63_DS_ODS_TERM,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_ACT|EMVTAGUPDATECONDITION_DET,0,160,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},

	{TAG_DF8101_DS_SUMMARY2,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA|EMVTAGUPDATECONDITION_DET,8,16,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},

	{TAG_DF8102_DS_SUMMARY3,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_RA|EMVTAGUPDATECONDITION_DET,8,16,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},

	{TAG_DF8104_BALANCE_BEFOREGAC, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_ACT|EMVTAGUPDATECONDITION_DET, 6, 6, EMVTAGFORMAT_N, EMVTAGTYPE_PAYPASS},

	{TAG_DF8105_BALANCE_AFTERGAC, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_ACT|EMVTAGUPDATECONDITION_DET, 6, 6, EMVTAGFORMAT_N, EMVTAGTYPE_PAYPASS},

	{TAG_DF8106_DATA_NEEDED, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_DET, 0, 65535, EMVTAGFORMAT_B, EMVTAGTYPE_PAYPASS},

	{TAG_DF8107_CDOL1_RELATED_DATA, EMVTAGUPDATECONDITION_K, 0, 255, EMVTAGFORMAT_B, EMVTAGTYPE_PAYPASS},

	{TAG_DF8108_DS_AC_TYPE,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_ACT|EMVTAGUPDATECONDITION_DET,1,1,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},

	{TAG_DF8109_DS_INPUT_TERM,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_ACT|EMVTAGUPDATECONDITION_DET,8,8,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},

	{TAG_DF810A_DS_ODS_INFO_FOR_READER,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_ACT|EMVTAGUPDATECONDITION_DET,1,1,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},

	{TAG_DF810B_DS_SUMMARY_STATUS,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_DET,1,1,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},

	{TAG_DF810C_KERNEL_ID,EMVTAGUPDATECONDITION_K,1,1,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},

	{TAG_DF810D_DSVN_TERM,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_DET,0,65535,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},

	{TAG_DF810E_POSTGAC_PUTDATA_STATUS,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_DET,1,1,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},

	{TAG_DF810F_PREGAC_PUTDATA_STATUS,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_DET,1,1,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},

	{TAG_DF8110_PROCEED_TO_FIRST_WRITE_FLAG,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_ACT|EMVTAGUPDATECONDITION_DET,1,1,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},

	{TAG_DF8111_PDOL_RELATED_DATA,EMVTAGUPDATECONDITION_K,0,255,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},

	{TAG_DF8112_TAGS_TO_READ, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_ACT|EMVTAGUPDATECONDITION_DET, 0, 255, EMVTAGFORMAT_B, EMVTAGTYPE_PAYPASS},

	{TAG_DF8113_TAGS_TO_READ_YET, EMVTAGUPDATECONDITION_K, 0, 255, EMVTAGFORMAT_B, EMVTAGTYPE_PAYPASS},

	{TAG_DF8114_REF_CONTROL_PARAM, EMVTAGUPDATECONDITION_K, 1, 1, EMVTAGFORMAT_B, EMVTAGTYPE_PAYPASS},

	{TAG_DF8115_ERROR_INDICATION, EMVTAGUPDATECONDITION_K, 6, 6, EMVTAGFORMAT_B, EMVTAGTYPE_PAYPASS},

	{TAG_DF8116_UI_REQUEST_DATA, EMVTAGUPDATECONDITION_K, 22, 22, EMVTAGFORMAT_B, EMVTAGTYPE_PAYPASS},

	{TAG_DF8117_CARDDATA_INPUT_CAP, EMVTAGUPDATECONDITION_K, 1, 1, EMVTAGFORMAT_B, EMVTAGTYPE_PAYPASS},

	{TAG_DF8118_CVMCAP_CVMREQ, EMVTAGUPDATECONDITION_K, 1, 1, EMVTAGFORMAT_B, EMVTAGTYPE_PAYPASS},

	{TAG_DF8119_CVMCAP_NOCVM, EMVTAGUPDATECONDITION_K, 1, 1, EMVTAGFORMAT_B, EMVTAGTYPE_PAYPASS},

	{TAG_DF811A_DEFAULT_UDOL, EMVTAGUPDATECONDITION_K, 3, 3, EMVTAGFORMAT_B, EMVTAGTYPE_PAYPASS},

	{TAG_DF811B_KERNEL_CONFIG, EMVTAGUPDATECONDITION_K, 1, 1, EMVTAGFORMAT_B, EMVTAGTYPE_PAYPASS},

	{TAG_DF811C_TORNLOG_MAX_LIFETIME, EMVTAGUPDATECONDITION_K, 2, 2, EMVTAGFORMAT_B, EMVTAGTYPE_PAYPASS},

	{TAG_DF811E_MSD_CVMCAP_CVMREQ,EMVTAGUPDATECONDITION_K,1,1,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},

	{TAG_DF811F_SECURITY_CAP, EMVTAGUPDATECONDITION_K, 1, 1, EMVTAGFORMAT_B, EMVTAGTYPE_PAYPASS},

	{TAG_DF8112_TAGS_TO_READ, EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_ACT|EMVTAGUPDATECONDITION_DET, 0, 256, EMVTAGFORMAT_B, EMVTAGTYPE_PAYPASS},

	{TAG_DF8120_TAC_DEFAULT,EMVTAGUPDATECONDITION_K,5,5,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},

	{TAG_DF8121_TAC_DENIAL,EMVTAGUPDATECONDITION_K,5,5,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},

	{TAG_DF8122_TAC_ONLINE,EMVTAGUPDATECONDITION_K,5,5,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},

	{TAG_DF8123_READER_CTL_FLOOR_LIMIT,EMVTAGUPDATECONDITION_K,6,6,EMVTAGFORMAT_N,EMVTAGTYPE_PAYPASS},

	{TAG_DF8124_READER_CTL_TRX_LIMIT_NOCDCVM,EMVTAGUPDATECONDITION_K,6,6,EMVTAGFORMAT_N,EMVTAGTYPE_PAYPASS},

	{TAG_DF8125_READER_CTL_TRX_LIMIT_CDCVM, EMVTAGUPDATECONDITION_K, 6, 6, EMVTAGFORMAT_N, EMVTAGTYPE_PAYPASS},

	{TAG_DF8126_READER_CVM_LIMIT,EMVTAGUPDATECONDITION_K,6,6,EMVTAGFORMAT_N,EMVTAGTYPE_PAYPASS},

	{TAG_DF8127_TIMEOUT_VALUE,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_DET,2,2,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},

	{TAG_DF8128_IDS_STATUS,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_DET,1,1,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},

	{TAG_DF8129_OUTCOME_PARAM_SET,EMVTAGUPDATECONDITION_K,8,8,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},

	{TAG_DF812A_DDCARD_TRACK1, EMVTAGUPDATECONDITION_K, 0, 56, EMVTAGFORMAT_ANS, EMVTAGTYPE_PAYPASS},

	{TAG_DF812B_DDCARD_TRACK2,EMVTAGUPDATECONDITION_K,0,8,EMVTAGFORMAT_CN,EMVTAGTYPE_PAYPASS},

	{TAG_DF812C_MSD_CVMCAP_NOCVM, EMVTAGUPDATECONDITION_K, 1, 1, EMVTAGFORMAT_B, EMVTAGTYPE_PAYPASS},

	{TAG_DF812D_MESSAGE_HOLD_TIME, EMVTAGUPDATECONDITION_K, 3, 3, EMVTAGFORMAT_N, EMVTAGTYPE_PAYPASS},

	{TAG_DF8130_HOLD_TIME_VALUE, EMVTAGUPDATECONDITION_K, 1, 1, EMVTAGFORMAT_B, EMVTAGTYPE_PAYPASS},

	{TAG_DF8131_PHONE_MESS_TABLE,EMVTAGUPDATECONDITION_K,0,8,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},

	{TAG_DF8132_MIN_RR_GRACE_PERIOD, EMVTAGUPDATECONDITION_K, 2, 2, EMVTAGFORMAT_B, EMVTAGTYPE_PAYPASS},

	{TAG_DF8133_MAX_RR_GRACE_PERIOD, EMVTAGUPDATECONDITION_K, 2, 2, EMVTAGFORMAT_B, EMVTAGTYPE_PAYPASS},

	{TAG_DF8134_TERMEXPECTTRANSTIME_FOR_RRP_CAPDU, EMVTAGUPDATECONDITION_K, 2, 2, EMVTAGFORMAT_B, EMVTAGTYPE_PAYPASS},

	{TAG_DF8135_TERMEXPECTTRANSTIME_FOR_RRP_RAPDU, EMVTAGUPDATECONDITION_K, 2, 2, EMVTAGFORMAT_B, EMVTAGTYPE_PAYPASS},

	{TAG_DF8136_RR_ACCURACY_THRESHOLD, EMVTAGUPDATECONDITION_K, 2, 2, EMVTAGFORMAT_B, EMVTAGTYPE_PAYPASS},

	{TAG_DF8137_RR_TRANSTIME_MISMATCH_THRESHOLD, EMVTAGUPDATECONDITION_K, 1, 1, EMVTAGFORMAT_B, EMVTAGTYPE_PAYPASS},

	{TAG_DF8301_TERM_RR_ENTROPY,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_DET,0,255,EMVTAGFORMAT_B, EMVTAGTYPE_PAYPASS},

	{TAG_DF8302_DEVICE_RR_ENTROPY,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_DET,0,4,EMVTAGFORMAT_B, EMVTAGTYPE_PAYPASS},

	{TAG_DF8303_MIN_TIME_FOR_PROCESS_RR_APDU,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_DET,0,2,EMVTAGFORMAT_B, EMVTAGTYPE_PAYPASS},

	{TAG_DF8304_MAX_TIME_FOR_PROCESS_RR_APDU,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_DET,0,2,EMVTAGFORMAT_B, EMVTAGTYPE_PAYPASS},

	{TAG_DF8305_DEVICE_EST_TRANSTIME_RR_RAPDU,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_DET,0,2,EMVTAGFORMAT_B, EMVTAGTYPE_PAYPASS},

	{TAG_DF8306_MEASURED_RR_PROCESS_TIME,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_DET,0,2,EMVTAGFORMAT_B, EMVTAGTYPE_PAYPASS},

	{TAG_DF8307_RRP_COUNTER,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_DET,1,1,EMVTAGFORMAT_B, EMVTAGTYPE_PAYPASS},

	{TAG_FF8102_TAGS_TO_WRITE_BEFOREGAC,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_ACT|EMVTAGUPDATECONDITION_DET,0,65535,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},

	{TAG_FF8103_TAGS_TO_WRITE_AFTERGAC,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_ACT|EMVTAGUPDATECONDITION_DET,0,65535,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},

	{TAG_FF8104_DATA_TO_SEND,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_DET,0,65535,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},

	{TAG_FF8105_DATA_RECORD,EMVTAGUPDATECONDITION_K,0,65535,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},

	{TAG_FF8106_DISCRETIONARY_DATA,EMVTAGUPDATECONDITION_K,0,255,EMVTAGFORMAT_B,EMVTAGTYPE_PAYPASS},

	{TAG_FF8113_TAGS_TO_WRITE_YET_AFTERGAC,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_DET,0,65535,EMVTAGFORMAT_B, EMVTAGTYPE_PAYPASS},

	{TAG_FF8114_TAGS_TO_WRITE_YET_BEFOREGAC,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_DET,0,65535,EMVTAGFORMAT_B, EMVTAGTYPE_PAYPASS},

	{TAG_FF8115_TAGS_MISSING_PDOLDATA_FLAG,EMVTAGUPDATECONDITION_K|EMVTAGUPDATECONDITION_DET,0,65535,EMVTAGFORMAT_B, EMVTAGTYPE_PAYPASS},
};


static const uint32_t g_template6F_list[]=
{
	TAG_0084_DF_NAME,
	TAG_00A5_FCI_PROPRIETARY_TEMPLATE,
};

static const uint32_t g_template70_list[]=
{
	TAG_0056_TRACK1DATA,
	TAG_0057_TRACK2_EQUIVALENT_DATA,
	TAG_005A_APPLICATION_PAN,
	TAG_008C_CDOL_1,
	TAG_008E_CVM_LIST,
	TAG_008F_CERTIFICATION_AUTHORITY_PUBLIC_KEY_INDEX,
	TAG_0090_ISSUER_PUBLIC_KEY_CERTIFICATE,
	TAG_0092_ISSUER_PUBLIC_KEY_REMAINDER,
	TAG_0093_SIGNED_STATIC_APPLICATION_DATA,
	TAG_5F24_APPLICATION_EXPIRATION_DATE,
	TAG_5F25_APPLICATION_EFFECTIVE_DATE,
	TAG_5F28_ISSUER_COUNTRY_CODE,
	TAG_5F30_SERVICE_CODE,
	TAG_5F34_APPLICATION_PAN_SEQUENCE,
	TAG_9F07_AUC,
	TAG_9F08_APPLICATION_VERSION_NUMBER_CARD,
	TAG_9F0D_ISSUER_ACTION_CODE_DEFAULT,
	TAG_9F0E_ISSUER_ACTION_CODE_DENIAL,
	TAG_9F0F_ISSUER_ACTION_CODE_ONLINE,
	TAG_9F19_TOKEN_REQUESTOR_ID,
	TAG_9F1F_TRACK1_DISCRETIONARY_DATA,
	TAG_9F20_TRACK2_DISCRETIONARY_DATA,
	TAG_9F24_PAYMENT_ACCOUNT_REFERENCE,
	TAG_9F32_ISSUER_PUBLIC_KEY_EXPONENT,
	TAG_9F42_APPLICATION_CURRENCY_CODE,
	TAG_9F44_APPLICATION_CURRENCY_EXPONENT,
	TAG_9F46_ICC_PUBLIC_KEY_CERTIFICATE,
	TAG_9F47_ICC_PUBLIC_KEY_EXPONENT,
	TAG_9F48_ICC_PUBLIC_KEY_REMAINDER,
	TAG_9F4A_SDA_TAG_LIST,
	TAG_9F51_DRDOL,
	TAG_9F5B_DSDOL,
	TAG_9F62_PCVC3_TRACK1,
	TAG_9F63_PUNATC_TRACK1,
	TAG_9F64_NATC_TRACK1,
	TAG_9F65_PCVC3_TRACK2,
	TAG_9F66_PUNATC_TRACK2,
	TAG_9F67_NATC_TRACK2,
	TAG_9F69_CARD_AUTHENTICATION_RELATED_DATA,
	TAG_9F6B_PAYPASSMSD_TRACK2DATA,
	TAG_9F6E_THIRD_PARTY_DATA,
};

static const uint32_t g_template77_list[]=
{
	TAG_0057_TRACK2_EQUIVALENT_DATA,
	TAG_005A_APPLICATION_PAN,
	TAG_0082_AIP,
	TAG_008C_CDOL_1,
	TAG_008E_CVM_LIST,
	TAG_008F_CERTIFICATION_AUTHORITY_PUBLIC_KEY_INDEX,
	TAG_0090_ISSUER_PUBLIC_KEY_CERTIFICATE,
	TAG_0092_ISSUER_PUBLIC_KEY_REMAINDER,
	TAG_0094_AFL,
	TAG_5F24_APPLICATION_EXPIRATION_DATE,
	TAG_5F25_APPLICATION_EFFECTIVE_DATE,
	TAG_5F28_ISSUER_COUNTRY_CODE,
	TAG_5F30_SERVICE_CODE,
	TAG_5F34_APPLICATION_PAN_SEQUENCE,
	TAG_9F07_AUC,
	TAG_9F08_APPLICATION_VERSION_NUMBER_CARD,
	TAG_9F0D_ISSUER_ACTION_CODE_DEFAULT,
	TAG_9F0E_ISSUER_ACTION_CODE_DENIAL,
	TAG_9F0F_ISSUER_ACTION_CODE_ONLINE,
	TAG_9F10_IAD,
	TAG_9F19_TOKEN_REQUESTOR_ID,
	TAG_9F1F_TRACK1_DISCRETIONARY_DATA,
	TAG_9F20_TRACK2_DISCRETIONARY_DATA,
	TAG_9F24_PAYMENT_ACCOUNT_REFERENCE,
	TAG_9F26_APPLICATION_CRYPTOGRAM,
	TAG_9F27_CRYPTOGRAM_INFO_DATA,
	TAG_9F32_ISSUER_PUBLIC_KEY_EXPONENT,
	TAG_9F36_ATC,
	TAG_9F42_APPLICATION_CURRENCY_CODE,
	TAG_9F44_APPLICATION_CURRENCY_EXPONENT,
	TAG_9F46_ICC_PUBLIC_KEY_CERTIFICATE,
	TAG_9F47_ICC_PUBLIC_KEY_EXPONENT,
	TAG_9F48_ICC_PUBLIC_KEY_REMAINDER,
	TAG_9F4A_SDA_TAG_LIST,
	TAG_9F4B_SIGNED_DYNAMIC_APPLICATION_DATA,
	TAG_9F54_DS_ODS_CARD,
	TAG_9F5F_DS_SLOT_AVAILABILITY,
	TAG_9F60_CVC3_TRACK1,
	TAG_9F61_CVC3_TRACK2,
	TAG_9F6F_DS_SLOT_MANAGE_CTRL,
	TAG_9F7D_DS_SUMMARY1,
	TAG_9F7F_DS_UNPREDICT_NUMBER,
	TAG_DF4B_POS_CARDHOLDER_INTERACT_INFO,
};

static const uint32_t g_templateA5_list[]=
{
	TAG_0050_APPLICATION_LABEL,
	TAG_006F_FCI_TEMPLATE,
	TAG_0087_API,
	TAG_5F2D_LANGUAGE_PREFERENCE,
	TAG_9F11_ISSUER_CODE_TABLE_INDEX,
	TAG_9F12_APPLICATION_PREFERRED_NAME,
	TAG_9F38_PDOL,
	TAG_BF0C_FCI_ISSUER_DISCRETIONARY_DATA,
};


static const uint32_t g_templateBF0C_list[]=
{
	TAG_008B_POI_INFOMATION,
//	TAG_5F53_IBAN,
	TAG_9F05_APPLICATION_DISCRETIONARY_DATA,
	TAG_9F3E_TERMINAL_CATEGORIES_SUPPORTED_LIST,
	TAG_9F3F_SDOL,
	TAG_9F4D_LOG_SFI,
	TAG_9F5D_APP_CAPABILITY_INFO,
	TAG_9F5E_DS_ID,
	TAG_9F6E_THIRD_PARTY_DATA,
};

uint32_t g_proprietary_tag_lib[32]={0};
uint8_t g_proprietary_tag_lib_sum=0;

int32_t emv_taglib_add_proprietary_tag(uint32_t tag)
{
	if(g_proprietary_tag_lib_sum > sizeof(g_proprietary_tag_lib)/sizeof(uint32_t) - 1)
	{
		return -1;
	}

	eTRACE("database-info: emv_taglib_add_proprietary_tag add tag: %03X", tag);
	g_proprietary_tag_lib[g_proprietary_tag_lib_sum++] = tag;

	return 0;
}

bool emv_taglib_find_proprietary_tag(uint32_t tag)
{
	int32_t i;

	for(i = 0; i < g_proprietary_tag_lib_sum; i++)
	{
		if(tag == g_proprietary_tag_lib[i])
		{
			return true;
		}
	}

	return false;
}

static int32_t binarysearch(const int32_t *arr, int32_t l, int32_t r, int32_t x)
{
	int32_t mid = l + (r - l) / 2;

	while (arr[mid] != x)
	{
		if (r <= l || r < 0)
		{
			 return -1;
		}

		if (arr[mid] > x)
       {
			 r = mid - 1;
		}
		else
		{
			 l = mid + 1;
		}

		mid = l + (r - l) / 2;
	}

    return mid;
}


uint8_t emv_taglib_read_UpdateCondition(uint32_t tag, uint32_t belong, uint8_t matchMode, uint8_t Update, EMV_TAG_ITEM *item)
{
	uint16_t size,left,right,mid;
	uint8_t readRes = 0;
	int32_t pos;

	if(tag <= 0)
	{
		return readRes;
	}

	size = sizeof(g_emv_tag_lib)/sizeof(g_emv_tag_lib[0]);
//	eTRACE("database-info: size = %d", size);

	left = 0;
	right = size - 1;
	readRes = 1;
	pos = -1;

//	eTRACE("database-info: mid start = %d", mid);

	//binary search
	while (left <= right)
	{
		mid = left + (right - left) / 2;

//		eTRACE("database-info: g_emv_tag_lib[mid].Tag = %03X", g_emv_tag_lib[mid].Tag);
//		eTRACE("database-info: tag = %03X", tag);
		if(g_emv_tag_lib[mid].Tag == tag)
		{
			if(1 == matchMode)	//match brand belong and update condition
			{
				if((g_emv_tag_lib[mid].belong & belong) && (g_emv_tag_lib[mid].Update & Update))
				{
					readRes = 0;
					pos = mid;
					break;
				}
				else
				{
					//found tag but not match belong and update,continue forward and backforward search six position
					int32_t foundPos = -1;
					int32_t i;
					for(i = 1; i <= 6; i++)
					{
						if((int32_t)mid - i < 0)
						{
							break;
						}

						if(g_emv_tag_lib[mid - i].Tag != tag)
						{
							break;
						}

						if((g_emv_tag_lib[mid - i].belong & belong) && (g_emv_tag_lib[mid - i].Update & Update))
						{
							foundPos = mid - i;
							break;
						}
					}

					if (foundPos == -1)
					{
						for (i = 1; i <= 6; i++)
						{
							// 如果越界了就退出
							if (mid + i >= size)
							{
								break;
							}

							if (g_emv_tag_lib[mid + i].Tag != tag)
							{
								break;
							}

							if ((g_emv_tag_lib[mid + i].belong & belong) && (g_emv_tag_lib[mid + i].Update & Update))
							{
								foundPos = mid + i;
								break;
							}
						}
					}

					if (foundPos >= 0)
					{
						readRes = 0;
						pos = foundPos;
					}

					break;
				}
			}
			else
			{
				readRes = 0;
				//not match belong and update condition,find left most same tag
                while (mid > 0 && g_emv_tag_lib[mid - 1].Tag == tag)
                {
                    mid--;
                }
                pos = mid;
                break;
			}
		}
		else if(g_emv_tag_lib[mid].Tag > tag)
		{
            if (mid == 0)	//Boundary restrictions
            {
                break;
            }
			right = mid - 1;
		}
		else
		{
			left = mid + 1;
		}

		mid = left + (right - left) / 2;

//		eTRACE("database-info: mid = %d", mid);
//		eTRACE("database-info: right = %d", right);
//		eTRACE("database-info: left = %d", left);
	}

	if(item != NULL)
	{
        emv_memset(item, 0, sizeof(EMV_TAG_ITEM));
        if (readRes == 0 && pos >= 0)
        {
            item->Tag     = g_emv_tag_lib[pos].Tag;
            item->Update  = g_emv_tag_lib[pos].Update;
            item->minLen  = g_emv_tag_lib[pos].minLen;
            item->maxLen  = g_emv_tag_lib[pos].maxLen;
            item->Format  = g_emv_tag_lib[pos].Format;
            item->belong  = g_emv_tag_lib[pos].belong;
        }
		else
		{
            item->Tag     = g_emv_tag_lib[pos].Tag;
		}
	}

	return readRes;
}

int32_t emv_taglib_ReadItemWithExactMatch(uint32_t tag, uint32_t belong, EMV_TAG_ITEM *item)
{
    uint16_t size, left, right, mid;
    int32_t pos = -1;
    int32_t i;

    if(item == NULL)
    {
        return EMV_ERR;
    }

    size = sizeof(g_emv_tag_lib)/sizeof(g_emv_tag_lib[0]);
    left = 0;
    right = size - 1;
    emv_memset((void *)item, 0, sizeof(EMV_TAG_ITEM));

	//binary search tagname
    while (left <= right)
    {
        mid = left + (right - left) / 2;

        if(g_emv_tag_lib[mid].Tag == tag)
        {
            pos = mid;
            break;
        }
        else if(g_emv_tag_lib[mid].Tag > tag)
        {
            if (mid == 0)
            {
                break;
            }
            right = mid - 1;
        }
        else
        {
            left = mid + 1;
        }
    }

    if(pos < 0)
    {
        return EMV_ERR;
    }

	//left forward check belong
    for(i = pos; i >= 0 && i >= pos - 10; i--)
    {
        if(g_emv_tag_lib[i].Tag != tag)
        {
            break;
        }

        if(g_emv_tag_lib[i].belong & belong)
        {
            pos = i;
            goto FOUND;
        }
    }

    // right forward check belong
    for(i = pos + 1; i < size && i <= pos + 10; i++)
    {
        if(g_emv_tag_lib[i].Tag != tag)
        {
            break;
        }

        if(g_emv_tag_lib[i].belong & belong)
        {
            pos = i;
            goto FOUND;
        }
    }

    // 如果都没找到
    return EMV_ERR;

FOUND:
    item->Tag    = g_emv_tag_lib[pos].Tag;
    item->Update = g_emv_tag_lib[pos].Update;
    item->minLen = g_emv_tag_lib[pos].minLen;
    item->maxLen = g_emv_tag_lib[pos].maxLen;
    item->Format = g_emv_tag_lib[pos].Format;
    item->belong = g_emv_tag_lib[pos].belong;

    return EMV_OK;
}

uint8_t emv_ParseExtLenWithMaxLen(uint8_t *ParseData,uint16_t *index,uint16_t *DataLen,uint16_t MaxLen)
{
	uint8_t t;
	uint16_t j,k,templen;

	k = *index;
	if(ParseData[k]<=127)
	{
		templen=ParseData[k];
		k++;
	}
	else
	{
		templen=0;
		t=ParseData[k]&0x7F;
		if(t>2)
		{
			return 1;
		}
		for(j=1; j<=t; j++)
		{
			if((k+j) > MaxLen)
		    {
		    	return 1;
		    }
			templen=templen*256+ParseData[k+j];
		}
		k += t+1;
	}
	*index = k;
	*DataLen = templen;
	return 0;
}

//C-2 Kernel-2 V2.11 Final page 69

int32_t GetItemFromList(uint32_t List, EMV_TLVOBJ *item_arry, int32_t size)
{
	uint8_t *list_ptr;
	int32_t len,ret;

	if(item_arry == NULL || size < 0)
	{
		return EMV_FAIL;
	}

	list_ptr = appdata_find(List, &len);
	if(list_ptr == NULL || len <= 0)
	{
		return EMV_FAIL;
	}

	return emvtlv_decode(list_ptr, len, item_arry, size, STRING_TLVOBJ);
}


int32_t GetTagFromList(uint32_t List, uint32_t *item_arry, int32_t size)
{
	uint8_t *list_ptr, *tmpbuf;
	int32_t len,i,tag_len,counter=0;

	if(item_arry == NULL || size < 0)
	{
		return 0;
	}

	list_ptr = appdata_find(List, &len);
	if(!list_ptr)
	{
		return 0;
	}

	while (i < len)
	{
		if(counter >= size)
		{
			break;
		}

		if((list_ptr[i] & 0x1F) == 0x1F)
		{
			if((list_ptr[i+1] & 0x80) == 0x80)
			{
				tag_len = 3;
			}
			else
			{
				tag_len = 2;
			}
		}
		else
		{
			tag_len = 1;
		}
		item_arry[counter++] = emv_hex2dec(list_ptr+i, tag_len);
		i += tag_len;
	}

	return counter;
}

uint8_t *GetAndRemoveFromList(uint32_t *itemLen, uint32_t List)
{
	uint8_t *list_ptr, *tmpbuf,*rest_buf;
	int32_t len,i,j,tag_len,list_len,len_byte,num_bytes;
	uint32_t sup_tags[] = {
	TAG_9F70_PROTECTED_DATA_ENVELOPE1,
	TAG_9F71_PROTECTED_DATA_ENVELOPE2,
	TAG_9F72_PROTECTED_DATA_ENVELOPE3,
	TAG_9F73_PROTECTED_DATA_ENVELOPE4,
	TAG_9F74_PROTECTED_DATA_ENVELOPE5,
	TAG_9F75_UNPROTECTED_DATA_ENVELOPE1,
	TAG_9F76_UNPROTECTED_DATA_ENVELOPE2,
	TAG_9F77_UNPROTECTED_DATA_ENVELOPE3,
	TAG_9F78_UNPROTECTED_DATA_ENVELOPE4,
	TAG_9F79_UNPROTECTED_DATA_ENVELOPE5,
	};
	uint32_t active_tag;
	bool sup_flag=false;

	list_ptr = appdata_find(List, &list_len);
	if(list_ptr == NULL && list_len == 0)
	{
		*itemLen = 0;
		return NULL;
	}

	i = 0;
	if(list_len > 1)
	{
		if(list_ptr[i] & 0x7F)
		{
			tag_len = 2;
		}
		else
		{
			tag_len = 1;
		}
	}
	else if(list_len == 1)
	{
		tag_len = 1;
	}
	else
	{
		tag_len = 0;
		*itemLen = 0;
		return NULL;
	}

	active_tag = emv_hex2dec(list_ptr, tag_len);
	for(j = 0; j < sizeof(sup_tags)/sizeof(uint32_t); j++)
	{
		if(active_tag == sup_tags[j])
		{
			sup_flag = true;
			break;
		}
	}

	if(!sup_flag)
	{
		*itemLen = 0;
		return NULL;
	}

	i += tag_len;

	if((list_ptr[i] & 0x80) == 0x00)
	{
		len_byte = 1;
		len = list_ptr[i];
		i++;
	}
	else
	{
		num_bytes = list_ptr[i] & 0x7F;  // 获取长度字节数
		len_byte = 1 + num_bytes;

		if (i + len_byte > list_len)
		{
			*itemLen = 0;
			return NULL;
		}

		len = 0;
		i++;

		for (j = 0; j < num_bytes; j++)
		{
			len = (len << 8) | list_ptr[i++];
		}

		// 检查长度是否合理（可选）
		if (len < 0 || len > 2048)
		{
			*itemLen = 0;
			return NULL;
		}
	}

	i += len;

	eTRACE("paypass-info: len = %d", len);
	eTRACE("paypass-info: i = %d", i);

	if(i > list_len)
	{
		*itemLen = 0;
		return NULL;
	}

	*itemLen = i;

	//warning, this API use malloc to get memory,must be free by caller
	tmpbuf = (uint8_t *)malloc(i);
	emv_memset(tmpbuf, 0, i);
	emv_memcpy(tmpbuf, list_ptr, i);

	if(list_len > i)
	{
		rest_buf = (uint8_t *)malloc(list_len - i);
		emv_memset(rest_buf, 0, list_len - i);
		emv_memcpy(rest_buf, list_ptr+i, list_len - i);
		appdata_save(List, rest_buf, list_len - i, OVERRIDED);
	}
	else
	{
		appdata_save(List, NULL, 0, OVERRIDED);
	}

	return tmpbuf;
}

uint32_t GetNextGetDataTagFromList(uint32_t List, bool remove)
{
	uint8_t *list_ptr;
	int32_t len,i,ret,j;
	uint8_t itemLen;
	uint8_t tmpbuf[2]={0};
	uint32_t active_tag;
	bool sup_flag = false;
	EMV_TAG_ITEM item={0};
	uint32_t sup_tags[] = {
		TAG_9F70_PROTECTED_DATA_ENVELOPE1,
		TAG_9F71_PROTECTED_DATA_ENVELOPE2,
		TAG_9F72_PROTECTED_DATA_ENVELOPE3,
		TAG_9F73_PROTECTED_DATA_ENVELOPE4,
		TAG_9F74_PROTECTED_DATA_ENVELOPE5,
		TAG_9F75_UNPROTECTED_DATA_ENVELOPE1,
		TAG_9F76_UNPROTECTED_DATA_ENVELOPE2,
		TAG_9F77_UNPROTECTED_DATA_ENVELOPE3,
		TAG_9F78_UNPROTECTED_DATA_ENVELOPE4,
		TAG_9F79_UNPROTECTED_DATA_ENVELOPE5,
	};

	list_ptr = appdata_find(List, &len);
	if((NULL == list_ptr) || ((list_ptr != NULL) && (0 == len)))
	{
		return 0;
	}

	eTRACE("paypass-info: start GetNextGetDataTagFromList");

	i = 0;

	eTRACE("paypass-info: len = %d", len);

	if(len < 1)
	{
		return 0;
	}
	else if(len == 1)
	{
		itemLen = 1;

		emv_memcpy(tmpbuf, list_ptr, itemLen);
		active_tag = emv_hex2dec(tmpbuf, itemLen);

		for(j = 0; j < sizeof(sup_tags)/sizeof(uint32_t); j++)
		{
			if(active_tag == sup_tags[j])
			{
				sup_flag = true;
				break;
			}
		}

		emv_memset((void *)&item, 0, sizeof(EMV_TAG_ITEM));
		ret = emv_taglib_ReadItemWithExactMatch(active_tag, EMVTAGTYPE_PAYPASS, &item);

		if(active_tag > 0 && ret == EMV_OK && sup_flag && remove)
		{
			if(List == TAG_DF8113_TAGS_TO_READ_YET)
			{
				remove_tag_from_tags2readyet(active_tag);
			}
			else if(List == TAG_FF8102_TAGS_TO_WRITE_BEFOREGAC)
			{
				remove_tag_from_tags2write_before_gac(active_tag);
			}
			return active_tag;
		}
		else
		{
			return 0;
		}
	}

	while (i < len)
	{
		if((list_ptr[i] & 0x1F) == 0x1F)
		{
			itemLen = 2;
		}
		else
		{
			itemLen = 1;
		}

		emv_memcpy(tmpbuf, list_ptr+i, itemLen);
		active_tag = emv_hex2dec(tmpbuf, itemLen);

		eTRACE("paypass-info: active_tag = %02X", active_tag);

		for(j = 0; j < sizeof(sup_tags)/sizeof(uint32_t); j++)
		{
			if(active_tag == sup_tags[j])
			{
				sup_flag = true;
				break;
			}
		}

		eTRACE("paypass-info: sup_flag = %s", sup_flag?"true":"false");
		eTRACE("paypass-info: remove = %s", remove?"true":"false");

		if(sup_flag && remove)
		{
			if(List == TAG_DF8113_TAGS_TO_READ_YET)
			{
				remove_tag_from_tags2readyet(active_tag);
			}
			else if(List == TAG_FF8102_TAGS_TO_WRITE_BEFOREGAC)
			{
				remove_tag_from_tags2write_before_gac(active_tag);
			}
		}

		emv_memset((void *)&item, 0, sizeof(EMV_TAG_ITEM));
		ret = emv_taglib_ReadItemWithExactMatch(active_tag, EMVTAGTYPE_PAYPASS, &item);
		eTRACE("paypass-info: emv_taglib_ReadItemWithExactMatch ret = %d", ret);

		if(sup_flag && active_tag > 0 && ret == EMV_OK)
		{
			return active_tag;
		}
		else
		{
			i+=itemLen;
		}
	}

	return 0;
}


bool IsEmptyList(uint32_t List)
{
	uint8_t *ptmp;
	int32_t len;

	ptmp = appdata_find(List, &len);

	if((NULL == ptmp) || ((ptmp != NULL) && (0 == len)))
	{
		return true;
	}
	else
	{
		return false;
	}
}

bool IsNotEmptyList(uint32_t List)
{
	return !(IsEmptyList(List));
}

bool IsItemIncludeList(uint8_t *item, uint8_t itemLen, uint32_t List)
{
	uint8_t *list_ptr;
	int32_t len,i;

	list_ptr = appdata_find(List, &len);
	if(IsEmptyList(List))
	{
		return false;
	}

	i = 0;

	while (i < len)
	{
		if(!emv_memcmp(item, list_ptr+i, itemLen))
		{
			return true;
		}
		i += itemLen;
	}

	return false;
}

//C-2 Kernel V2.11 Page 63
bool IsKnown(uint32_t tag)
{
	int32_t i;

	for(i = 0; i < sizeof(g_emv_tag_lib)/sizeof(g_emv_tag_lib[0]); i++)
	{
		if((g_emv_tag_lib[i].Tag == tag) && (g_emv_tag_lib[i].belong & EMVTAGTYPE_PAYPASS))
		{
			return true;
		}
	}

	return false;
}

bool IsPresent(uint32_t tag)
{
	uint8_t *ptmp;
	int32_t len;


	ptmp = appdata_find(tag, &len);
	if(ptmp != NULL)
	{
		return true;
	}
	else
	{
		return false;
	}
}

bool IsNotPresent(uint32_t tag)
{
	return !(IsPresent(tag));
}

bool IsNotEmpty(uint32_t tag)
{
	uint8_t *ptmp;
	int32_t len;

	ptmp = appdata_find(tag, &len);
	if(ptmp != NULL && len > 0)
	{
		return true;
	}
	else
	{
		return false;
	}
}

bool IsEmpty(uint32_t tag)
{
	uint8_t *ptmp;
	int32_t len;

	ptmp = appdata_find(tag, &len);
	if(ptmp != NULL && len == 0)
	{
		return true;
	}
	else
	{
		return false;
	}
}

void Initialize(uint32_t tag)
{
	if(0 == tag)
	{
		return ;
	}

	appdata_save(tag, NULL, 0, OVERRIDED);
}

int32_t GetTagLength(uint32_t tag)
{
    int32_t length = 0;

    while (tag > 0)
	{
        tag >>= 8;
        length++;
    }

    return length;
}

uint8_t *GetTagName(uint32_t ui_tag)
{
	int32_t length = GetTagLength(ui_tag);
	uint8_t *uc_tag;
	int32_t i;

	uc_tag = (uint8_t *)malloc(length);
	emv_memset(uc_tag, 0, length);

	for(i = 0; i < length; i++)
	{
		uc_tag[i] = (uint8_t)((ui_tag >> (8 * (length - i - 1))) & 0xFF);
	}

	return uc_tag;
}

//this function use malloc,need to free outside by caller
EMV_TLVOBJ GetTLV(uint32_t tag)
{
	uint8_t *ptmp;
	int32_t len;
	EMV_TLVOBJ tlv = {0};

	ptmp = appdata_find(tag, &len);
	if(ptmp != NULL && len > 0)
	{
		tlv.tagname = tag;
		tlv.valuelen = len;
		tlv.pvalue = (uint8_t *)malloc(tlv.valuelen);
		emv_memset(tlv.pvalue, 0, tlv.valuelen);
		emv_memcpy(tlv.pvalue, ptmp, tlv.valuelen);

		return tlv;
	}

	return tlv;
}

int32_t GetLength(uint32_t tag)
{
	uint8_t *ptmp;
	int32_t len;

	ptmp = appdata_find(tag, &len);
	if(ptmp != NULL)
	{
		return len;
	}
	else
	{
		return -1;
	}
}

bool IsTagPrivateClass(uint32_t tag_dec)
{
	uint8_t tag_hex[3] ={0};

	emv_dec2hex(tag_dec, tag_hex, 3);

	if(0xC0 == (tag_hex[0] & 0xC0))
	{
		return true;
	}

	return false;
}

uint8_t GetTagUpdateCondition(uint32_t tag, uint32_t belong)
{
	int32_t i;

	for(i = 0; i < sizeof(g_emv_tag_lib)/sizeof(g_emv_tag_lib[0]); i++)
	{
		if((tag == g_emv_tag_lib[i].Tag) && (g_emv_tag_lib[i].belong & belong))
		{
			return g_emv_tag_lib[i].Update;
		}
	}

	return 0x00;
}

int32_t OutputTLV(EMV_TLVOBJ *tlvs, int32_t tlv_size, uint8_t *output, int32_t output_size)
{
	int32_t i=0,pos,tag_len,j;
	uint8_t tag[3]={0};

	if(tlvs == NULL || tlv_size < 0 || output == NULL || output_size < 0)
	{
		return EMV_FAIL;
	}

	eTRACE("paypass-info: tlvs[1].childnum = %d", tlvs[1].childnum);

	for(pos = 2; pos < tlvs[1].childnum+2; pos++)
	{
		tag_len = GetTagLength(tlvs[pos].tagname);

		emv_memset(tag, 0, sizeof(tag));

		emv_dec2hex(tlvs[pos].tagname, tag, tag_len);

		eTRACE_HEX("paypass-info: OutputTLV tag", tag, tag_len);

		emv_memcpy(output+i, tag, tag_len);
		i += tag_len;
		output[i++] = tlvs[pos].valuelen;
		emv_memcpy(output+i, tlvs[pos].pvalue, tlvs[pos].valuelen);
		i += tlvs[pos].valuelen;
	}

	return i;
}

bool IsTagIncludeTemplateValid(uint32_t tag, uint32_t tmplate, uint8_t RFU)
{
	int32_t i,size,left,right,mid;

	eTRACE("paypass-info: input tmplate = %02X", tmplate);

	if(TAG_00A5_FCI_PROPRIETARY_TEMPLATE == tmplate)
	{
		for(i = 0; i < sizeof(g_templateA5_list)/sizeof(uint32_t); i++)
		{
			if(tag == g_templateA5_list[i])
			{
				return true;
			}
		}
	}
	else if(TAG_BF0C_FCI_ISSUER_DISCRETIONARY_DATA == tmplate)
	{
		for(i = 0; i < sizeof(g_templateBF0C_list)/sizeof(uint32_t); i++)
		{
			if(tag == g_templateBF0C_list[i])
			{
				return true;
			}
		}
	}
	else if(TAG_006F_FCI_TEMPLATE == tmplate)
	{
		for(i = 0; i < sizeof(g_template6F_list)/sizeof(uint32_t); i++)
		{
			if(tag == g_template6F_list[i])
			{
				return true;
			}
		}
	}
	else if(TAG_0070_AEF_DATA_TEMPLATE == tmplate)
	{
		size = sizeof(g_template70_list)/sizeof(uint32_t);

		left = 0;
		right = size - 1;

		//binary search
		while (left <= right)
		{
			mid = left + (right - left) / 2;

			if(g_template70_list[mid] == tag)
			{
				return true;
			}
			else if(g_template70_list[mid] > tag)
			{
				if (mid == 0)	//Boundary restrictions
				{
					break;
				}
				right = mid - 1;
			}
			else
			{
				left = mid + 1;
			}

			mid = left + (right - left) / 2;
		}
	}
	else if(TAG_0077_RESPONSE_MESSAGE_TEMPLATE_FORMAT_2 == tmplate)
	{
		size = sizeof(g_template77_list)/sizeof(uint32_t);

		left = 0;
		right = size - 1;

		//binary search
		while (left <= right)
		{
			mid = left + (right - left) / 2;

			if(g_template77_list[mid] == tag)
			{
				return true;
			}
			else if(g_template77_list[mid] > tag)
			{
				if (mid == 0)	//Boundary restrictions
				{
					break;
				}
				right = mid - 1;
			}
			else
			{
				left = mid + 1;
			}

			mid = left + (right - left) / 2;
		}
	}
	else if(0xFFFFFFFF == tmplate)
	{
		return true;
	}

	return false;
}

//0xA5 is the template A5 of select command response
//0x70 is the template 70 of read record cpmmand response
//0x77 is the template 77 of CCC command(COMPUTE CRYPTOGRAPHIC CHECKSUMMSD, only in MSD) and GAC command response
//0xBF is the template BF0C of template A5
//0x01 is the response of GET DATA command
//0x6F is the template 6F of template A5
//0x02 is the template 77 of GPO command

bool ParseAndStoreCardResponse(uint8_t *resp, int32_t resp_len, uint32_t tmplate, EMV_TLVOBJ *tlvs, int32_t tlvs_size)
{
	uint8_t command = 0x00;
	bool err_flg = false;
	EMV_TAG_ITEM item = {0};
	int32_t ret, i;

	eTRACE("paypass-info: start ParseAndStoreCardResponse");
	ret = emvtlv_decode(resp, resp_len, tlvs, tlvs_size, SINGLE_TLVOBJ);

	eTRACE("paypass-info: emvtlv_decode ret = %d", ret);
	if(ret < 0)
	{
		err_flg = true;
	}
	eTRACE("paypass-info: err_flg = %d", err_flg);
	if(err_flg)
	{
		return false;
	}
	else
	{
		for(i = 1; i < tlvs[0].childnum+1; i++)
		{
			ret = emv_taglib_ReadItemWithExactMatch(tlvs[i].tagname, EMVTAGTYPE_PAYPASS, &item);
			eTRACE("paypass-info: emv_taglib_ReadItemWithExactMatch ret = %d", ret);

			if(EMVTAGUPDATECONDITION_RA & item.Update)
			{
				eTRACE("paypass-info: flag35");
				if(IsKnown(tlvs[i].tagname))
				{
					eTRACE("paypass-info: flag36");
					if((IsNotPresent(tlvs[i].tagname) || IsEmpty(tlvs[i].tagname)) && \
					   (tlvs[i].valuelen >= item.minLen && tlvs[i].valuelen <= item.maxLen) && \
					   IsTagIncludeTemplateValid(tlvs[i].tagname, tmplate, command))
					{
						eTRACE("paypass-info: flag37");
						appdata_save(tlvs[i].tagname, tlvs[i].pvalue, tlvs[i].valuelen, OVERRIDED);
						eTRACE("paypass-info: flag38");
					}
					else
					{
						return false;
					}
				}
				else
				{
					eTRACE("paypass-info: flag39");
					if(IsEmpty(tlvs[i].tagname))
					{
						appdata_save(tlvs[i].tagname, tlvs[i].pvalue, tlvs[i].valuelen, OVERRIDED);
					}
					else
					{
						return false;
					}
				}
			}
		}

		return true;
	}
}
